# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\PID;..\HARDWARE\SEEK;..\HARDWARE\WAVE;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\VL53L0;..\HARDWARE\duoji;..\HARDWARE\GY26;..\HARDWARE\ALLOCATION;..\HARDWARE\INFRARED;..\HARDWARE\SERVO;..\HARDWARE\MPU6050;..\HARDWARE\usart2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c test.c part.c section.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/SEEK/: seek.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/ALLOCATION/: allocation.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/SERVO/: servo_ctrl.c
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HARDWARE/usart2/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c
  group README
    ../: README.TXT
